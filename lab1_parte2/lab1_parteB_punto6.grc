options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Lab1_punto6
    output_language: python
    title: Lab1_punto6
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    label: ancho de banda
    start: '10'
    step: '10'
    stop: '50000'
    value: '1500'
  states: {}
- name: f_corte
  id: variable_qtgui_range
  parameters:
    label: frecuencia de corte
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia central
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: fc+bw/2
    interp: '1'
    low_cutoff_freq: fc-bw/2
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/GNURADIO_LABCOMUIS_2023_1_L1C_G2-main/lab1_parte2/algomegustadeti_WY.wav-20230412T193929Z-001/algomegustadeti_WY.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [high_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
